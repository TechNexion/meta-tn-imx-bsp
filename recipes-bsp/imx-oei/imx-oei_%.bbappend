SRC_URI = "${IMX_OEI_SRC};branch=${SRCBRANCH}"
IMX_OEI_SRC = "git://github.com/TechNexion/imx-oei.git;protocol=https"
SRCBRANCH = "tn-imx_6.18.20_2.0.0"
SRCREV = "28e75a7791c38a6e38ce2400511a9835eeb30d6f"