SRC_URI = "${IMX_OEI_SRC};branch=${SRCBRANCH}"
IMX_OEI_SRC = "git://github.com/TechNexion/imx-oei.git;protocol=https"
SRCBRANCH = "tn-imx_6.12.49_2.2.0"
SRCREV = "8593c67893ad06160ec22d67e078b6ad12bf5ea1"