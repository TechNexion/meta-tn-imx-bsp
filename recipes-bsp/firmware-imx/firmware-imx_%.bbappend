IS_MX8_pico-imx8m = "8mq"

