IS_MX8_mx8m = "8mq"
IS_MX8_mx8mm = "8mq"
