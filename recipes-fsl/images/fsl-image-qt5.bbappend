# add package for edm release image
IMAGE_INSTALL += " \
    chromium \
    "
