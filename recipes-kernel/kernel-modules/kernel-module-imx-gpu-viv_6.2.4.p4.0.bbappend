# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2018 TechNexion Ltd.
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

SRCBRANCH = "tn-imx_4.14.98_2.0.0_ga-next"
KERNEL_SRC = "git://github.com/TechNexion/linux-tn-imx.git"
SRCREV = "186eccf6787ad9f1ae90fcabaf63ba3bcd874a79"
