RDEPENDS_${PN} += "perl"

