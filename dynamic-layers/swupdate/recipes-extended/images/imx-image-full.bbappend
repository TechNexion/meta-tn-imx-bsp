IMAGE_FSTYPES:append:swu = " ext4.gz"

IMAGE_INSTALL:append:swu-single = " swupdate"
WKS_FILE:swu-single = "tn-swu-single-imx-boot-bootpart.wks.in"
