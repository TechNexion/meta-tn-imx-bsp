FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-engine-DemoPage-add-the-code-for-parse-TechNexion-bo.patch"

