FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Delete-the-set-camera-framerate-to-pipline-and-chang.patch"
