FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-demos-fix-xdg-shell-header-build-dependency.patch"
