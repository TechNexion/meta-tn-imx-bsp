FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:remove = " file://0001-spa-libcamera-fix-RGB-mappings.patch"
