IMAGE_INSTALL += " packagegroup-tn-wlan"
