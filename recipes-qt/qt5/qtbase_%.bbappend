FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-examples-touch-fingerpaint-resize-the-window-to-scre.patch"

