COMPATIBLE_MACHINE="(mx8|mx8m|mx8mm|pico-imx8m|pico-imx8mm)"
