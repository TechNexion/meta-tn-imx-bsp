PROVIDES_OPENGLES3:mx8mm-nxp-bsp = "virtual/libgles3"
