DEPENDS_remove = "optee-os-imx"
DEPENDS_append = " optee-os-imx-tn"