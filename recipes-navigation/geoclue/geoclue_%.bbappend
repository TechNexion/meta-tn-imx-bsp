PACKAGECONFIG:remove = "${@bb.utils.contains('DISTRO_FEATURES', '3g', '3g modem-gps cdma', '', d)}"