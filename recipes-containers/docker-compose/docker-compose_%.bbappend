PACKAGECONFIG:remove = "docker-plugin"