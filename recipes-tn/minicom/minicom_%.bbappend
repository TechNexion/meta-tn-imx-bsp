FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-sysdep-fix-baudrate-with-glibc-2.42.patch"